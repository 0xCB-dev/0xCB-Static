File: PCB/plate-top/plate-top.kicad_pcb (KiCad board)
At the start: 2 copper layers, 238.6 x 84.7 mm, 4 parts

Commit message: updated prod files
Other:
- outline, holes or cut-outs redrawn
